# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.h Delay.c Delay.h LCD1602.c OneWire.h OneWire.c DS18B20.h DS18B20.c I2C.c I2C.h Key.c Key.h AT24C02.c AT24C02.h Timer0.c Timer0.h
